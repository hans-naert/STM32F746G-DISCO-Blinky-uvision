# Keil uVision project STM32F746G-DISCO-Blinky-uvision.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20010000,0x0003C000) IROM(0x08000000,0x00100000) IROM2(0x00200000,0x00100000) XRAM(0x2004C000,0x00004000) XRAM2(0x40024000,0x00001000) XRAM3(0x00000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: STM32F746G-DISCO-Blinky-uvision
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: RAM 0x2004c000 size 0x4000
  memory RVCT7: RAM 0x40024000 size 0x1000
  memory RVCT8: RAM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x3c000
  group :CubeMX:CubeMX
    ./STM32CubeMX/Target_1/STM32CubeMX/Src/: main.c stm32f7xx_it.c stm32f7xx_hal_msp.c system_stm32f7xx.c
    ./STM32CubeMX/Target_1/STM32CubeMX/MDK-ARM/: startup_stm32f746xx.s
  group :CubeMX:STM32 HAL Driver
    ./STM32CubeMX/Target_1/STM32CubeMX/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c
software components: CMSIS:CORE 6.1.1, Device:CubeMX 1.0.0
